# Keil uVision project BDSMS_new.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: BDSMS_new +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: HXHD_SZTH.c PG.C RD.C TTCA.c ES.c PS.C ICOUT.c
